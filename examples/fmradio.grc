options:
  parameters:
    author: Mario Schulz
    description: Radio hören
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM_Rec
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Bandwidth
    labels: '[''200'', ''300'', ''600'', ''1536'', ''5000'', ''6000'', ''7000'', ''8000'']'
    num_opts: '0'
    options: '[200, 300, 600, 1536, 5000, 6000, 7000, 8000]'
    type: int
    value: '1536'
  states: {}
- name: down_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Frequenz
    label0: hr1
    label1: hr2
    label2: hr3
    label3: radio X
    num_opts: '4'
    option0: 94.4e6
    option1: 96.7e6
    option2: 89.3e6
    option3: 91.8e6
    type: real
    value: 89.3e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '20'
    step: '1'
    stop: '59'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_KAISER
  states: {}
- name: msz_rsp1a_0
  id: msz_rsp1a
  parameters:
    bw: bandwidth
    frequency: frequency
    gain: gain
    sample_rate: samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/50
    fc: frequency
    fftsize: '1024'
    gui_hint: 1,0,2,4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [msz_rsp1a_0, '0', low_pass_filter_0, '0']
- [msz_rsp1a_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
