options:
  parameters:
    author: Mario Schulz
    copyright: GPL
    generate_options: qt_gui
    id: my_cw
    output_language: python
    title: My CW TEst
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '40'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr
      from sklearn.cluster import KMeans

      morse ={
          # codes from https://de.wikipedia.org/wiki/Morsezeichen
          # Letters
          "A": ".-",
          "B": "-...",
          "C": "-.-.",
          "D": "-..",
          "E": ".",
          "F": "..-.",
          "G": "--.",
          "H": "....",
          "I": "..",
          "J": ".---",
          "K": "-.-",
          "L": ".-..",
          "M": "--",
          "N": "-.",
          "O": "---",
          "P": ".--.",
          "Q": "--.-",
          "R": ".-.",
          "S": "...",
          "T": "-",
          "U": "..-",
          "V": "...-",
          "W": ".--",
          "X": "-..-",
          "Y": "-.--",
          "Z": "--..",
          # Figures
          "1": ".----",
          "2": "..---",
          "3": "...--",
          "4": "....-",
          "5": ".....",
          "6": "-....",
          "7": "--...",
          "8": "---..",
          "9": "----.",
          "0": "-----",
          # Accented
          "À": ".--.-",
          "Ä": ".-.-",
          "È": ".-..-",
          "É": "..-..",
          "Ö": "---.",
          "Ü": "..--",
          "ß": "...--..",
          "CH": "----",
          "~N": "--.--",   # correct that
          # Special characters
          ".": ".-.-.-",   # (AAA) dot
          ",": "--..--",   # (MIM) comma
          ":": "---...",   # (OS)  colon
          ";": "-.-.-.",   # (NNN) semicolon
          "?": "..--..",   # (IMI) question
          "!": "-.-.--",   #       exclamation
          "-": "-....-",   # (BA)  dash
          "_": "..--.-",   # (UK)  underscore
          "(": "-.--.",    # (KN)  bracket open
          ")": "-.--.-",   # (KK)  bracket close
          "'": ".----.",   # (JN)  single quote
          "\"": ".-..-.",  #       double quote
          "=": "-...-",    # (BT)  equals
          "+": ".-.-.",    # (AR)  plus
          "/": "-..-.",    # (DN)  slash
          "@": ".--.-.",   # (AC)  at
          # Signals
          "<KA>": "-.-.-",  # Spruchnfang
          "<BT>": "-...-",  # Pause
          "<AR>": ".-.-.",  # Spruchende
          "<VE>": "...-.",  # verstanden
          "<SK>": "...-.-", # Verkehrsende
          "<SOS>": "...---...", # internationater (See-)Notruf
          "<HH>": "........"    # Fehler, Wiederholung ab letztem vollständigen Wort"
      }
       
      morse_inv = dict((v,k) for (k,v) in morse.items())

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block CW Decoder"""

          def handler_msg(self, msg):
              event = pmt.to_long(msg);
              distance = (event>>1)-(self.previous>>1)
              if (event & 1) == 0:		# State changed to zero, we got lenght of on
                  self.onvector[self.eventcount_on % self.learning_vector] = [distance]
                  self.eventcount_on += 1
                  if distance < self.middle:
                      self.letter += '.'
                  else:
                      self.letter += '-'
              else:
                  self.offvector[self.eventcount_off % self.learning_vector] = [distance]
                  self.eventcount_off += 1
                  if distance > self.middle_space_letter:
                      decoded_letter = morse_inv.get(self.letter, '<?>')
                      print(decoded_letter, self.letter)
                      self.word += decoded_letter
                      self.letter = ''
                  if distance > self.middle_space_word:
                      print('Word: ' + self.word)
                      self.word = ''
              if (self.eventcount+1) % 20 == 0:
                  #print(self.onvector)
                  self.kmeans_dd.fit(self.onvector)
                  y_kmeans = self.kmeans_dd.predict(self.onvector)
                  centers = self.kmeans_dd.cluster_centers_
                  dot, dash = (centers[0][0], centers[1][0]) if centers[0][0] < centers[1][0] else (centers[1][0], centers[0][0])
                  self.middle = (dot+dash)/2
                  diff = dash-dot
                  self.low = dot-diff
                  self.high = dash+diff
                  print('low: {:f} dot: {:f} middle: {:f} dash: {:f} high: {:f}'.format(self.low, dot, self.middle, dash, self.high))
                  #print(self.offvector)
                  self.kmeans_space.fit(self.offvector)
                  y_kmeans = self.kmeans_space.predict(self.offvector)
                  centers = self.kmeans_space.cluster_centers_
                  spaces = []
                  for i in centers:
                      spaces.append(i[0])
                  sorted_spaces = sorted(spaces)
                  print('spaces: ', sorted_spaces)
                  self.middle_space_letter = (sorted_spaces[0]+sorted_spaces[1]) / 2
                  self.middle_space_word = (sorted_spaces[1]+sorted_spaces[2]) / 2
              self.previous = event
              self.eventcount += 1

          def __init__(self, learning_vector=1000, initial_dit_length_samples=50):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CW (Morse) Decoder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.complex64]
              )
              self.message_port_register_in(pmt.intern("cwevent"))
              self.set_msg_handler(pmt.intern("cwevent"), self.handler_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.learning_vector = learning_vector
              self.eventcount = 0
              self.eventcount_on = 0
              self.eventcount_off = 0
              self.previous = 0
              self.kmeans_dd = KMeans(n_clusters=2)  # dash or dot
              self.kmeans_space = KMeans(n_clusters=3)  # letter space, word space, transmission space
              self.letter = ''
              self.word = ''
              self.middle = 0
              self.middle_space_letter = 0
              self.middle_space_word = 0
              if False:
                  self.onvector = [[0]]*self.learning_vector
                  self.offvector = [[0]]*self.learning_vector
              else:
                  self.onvector = []
                  self.offvector = []
                  for i in range(0, self.learning_vector):
                      if i % 1 == 0:
                          # initial length of dot
                          self.onvector.append([initial_dit_length_samples])
                      else:
                          # initial lenghth of dash
                          self.onvector.append([initial_dit_length_samples*2])
                      if i % 3 == 0:
                          # initial length of signal spacing
                          self.offvector.append([initial_dit_length_samples])
                      elif i % 3 == 1:
                          # initial length of letter spacing
                          self.offvector.append([initial_dit_length_samples*3])
                      else:
                          # initial length of word spacing
                          self.offvector.append([initial_dit_length_samples*7])
                      
                      

              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    initial_dit_length_samples: '4800'
    learning_vector: '1000'
  states: {}
- name: msz_cw_0
  id: msz_cw
  parameters:
    avg_len: '24'
    hyst_high: '0.5'
    hyst_low: '0.1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Not too realistic for a morse generator, just giving out arbitray length 0s and 1s.
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Audio Bcast
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_int_to_float_0, '0', epy_block_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', msz_cw_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_xx_0, '0', blocks_null_sink_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [msz_cw_0, '0', qtgui_time_sink_x_0, '2']
- [msz_cw_0, '0', qtgui_time_sink_x_2, '1']
- [msz_cw_0, '1', blocks_int_to_float_0, '0']
- [msz_cw_0, cwevent, epy_block_0, cwevent]
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
