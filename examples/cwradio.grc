options:
  parameters:
    author: Mario Schulz
    generate_options: qt_gui
    id: CW_Rec
    output_language: python
    title: Morse reception
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Frequenz
    label0: Bake Feldberg
    label1: hr3
    num_opts: '2'
    option0: 144475e3
    option1: 89.3e6
    type: real
    value: 144475e3
    widget: radio_buttons
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '20'
    step: '1'
    stop: '59'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '200'
    gain: '1'
    high_cutoff_freq: '500'
    low_cutoff_freq: '50'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: msz_rsp1a_0
  id: msz_rsp1a
  parameters:
    frequency: frequency
    gain: gain
    sample_rate: samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: 1,0,6,3
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1000'
    fc: '0'
    fftsize: '128'
    gui_hint: 1,0,6,3
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '441'
    taps: ''
    type: ccc
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [msz_rsp1a_0, '0', band_pass_filter_0, '0']
- [msz_rsp1a_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
